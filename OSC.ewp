# IAR project OSC.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LPC2148 NXP LPC2148
  ICCARM.CCIncludePath2: app\; modules\; Includes\; Drivers; modules\Commands\; modules\Commands\Include; 
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: OSC.hex
  ILINK.IlinkOutputFile: OSC.out
  ILINK.IlinkIcfFile: config\LPC2148_flash.icf
  ILINK.IlinkExtraOptions: --no_remove
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    App/: cstartup.asm main.c
    app/: exception.c
  group Drivers
    Drivers/: Backlight.c drv_hd44780.c drv_hd44780_l.c DS1820.c ir.c Out.c
  group Includes
    Includes/: Commands.h Console.h ConsoleCommands.h ConsoleHelp.h DlyZare.h drv_hd44780.h drv_hd44780_cnfg.h drv_hd44780_l.h DS1820.h Global_Defines.h i2c.h Includes.h InitializationZare.h ir.h menu.h Out.h PWM.h rtc.h StatusHandling.h SurfaceFlinger.h SystemZare.h Temperature.h TimerZare.h UART0Zare.h VICZare.h
  group modules
    Modules/: Commands.c ConsoleCommands.c ConsoleHelp.c StatusHandling.c
    modules/: Console.c Dly.c i2c.c menu.c MenuCallbacks.c PWM.c rtc.c SurfaceFlinger.c System.c Temperature.c Timer.c UART_Zare.c VIC.c
  group modules/Commands
    Modules/Commands/: Command.c Command.h Command_Debug.h Command_Defconfig.h Command_Defines.h Command_Func.h How_To_Create_Command_README.txt
  group modules/Commands/cmd_src
    Modules/Commands/cmd_src/: cmd_help.c cmd_info.c cmd_set_time.c cmd_time.c
  group modules/Debug
    Modules/Debug/: Func_Trace.c Func_Trace.h
  group UserFunc
    App/: initialization.c
