# IAR project SmartHome.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LPC2148 NXP LPC2148
  ICCARM.CCIncludePath2: App\; Modules\; Modules\Commands\; Modules\Console\; Modules\Debug\; Modules\Delay\; Modules\Display\; Modules\Menu\; Modules\Temperature\; Includes\; Drivers\; Drivers\Backlight\PWM_Backlight\; Drivers\Display_HD44780\; Drivers\IR\; Drivers\Switches\; Drivers\Temperature_Sensors\; SOC_HAL\CLK_Reset\; SOC_HAL\I2C\; SOC_HAL\MAM\; SOC_HAL\PWM\; SOC_HAL\RTC\; SOC_HAL\Timers\; SOC_HAL\UART\; SOC_HAL\VIC\; 
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: SmartHome.hex
  ILINK.IlinkOutputFile: SmartHome.out
  ILINK.IlinkIcfFile: config\LPC2148_flash.icf
  ILINK.IlinkExtraOptions: --no_remove
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: c.srec
  group App
    App/: cstartup.asm initialization.c Initialization.h main.c
  group Drivers/Backlight/PWM_Backlight
    Drivers/Backlight/PWM_Backlight/: PWM_Backlight.c PWM_Backlight.h PWM_Backlight_Debug.h PWM_Backlight_Defconfig.h PWM_Backlight_Func.h
  group Drivers/Display_HD44780
    Drivers/Display_HD44780/: HD44780.c HD44780.h HD44780_cnfg.h HD44780_l.c HD44780_l.h
  group Drivers/IR
    Drivers/IR/: TSOP1738.c TSOP1738.h
  group Drivers/Switches
    Drivers/Switches/: Out.c Out.h
  group Drivers/Temperature_Sensors
    Drivers/Temperature_Sensors/: DS1820.c DS1820.h
  group Includes
    Includes/: Commands.h ConsoleCommands.h ConsoleHelp.h Global_Defines.h Includes.h StatusHandling.h
  group Modules
    Modules/: Commands.c ConsoleCommands.c ConsoleHelp.c StatusHandling.c
  group Modules/Commands
    Modules/Commands/: Command.c Command.h Command_Defconfig.h Command_Func.h How_To_Create_Command_README.txt
  group Modules/Commands/cmd_src
    Modules/Commands/cmd_src/: cmd_bl.c cmd_date.c cmd_help.c cmd_info.c cmd_ir.c cmd_set_date.c cmd_set_time.c cmd_time.c
  group Modules/Console
    Modules/Console/: Console.c Console.h Console_Defconfig.h Console_Func.h
  group Modules/Debug
    Modules/Debug/: Exception.c Func_Trace.c Func_Trace.h
  group Modules/Delay
    Modules/Delay/: Delay.c Delay.h Delay_Func.h
  group Modules/Display
    Modules/Display/: SurfaceFlinger.c SurfaceFlinger.h
  group Modules/Menu
    Modules/Menu/: Menu.c Menu.h MenuCallbacks.c
  group Modules/Temperature
    Modules/Temperature/: Temperature.c Temperature.h
  group SOC_HAL/CLK_Reset
    SOC_HAL/CLK_Reset/: CLK_Reset.c CLK_Reset.h CLK_Reset_Defconfig.h CLK_Reset_Func.h
  group SOC_HAL/I2C
    SOC_HAL/I2C/: I2C.c I2C.h
  group SOC_HAL/MAM
    SOC_HAL/MAM/: MAM.c MAM.h MAM_Func.h
  group SOC_HAL/PWM
    SOC_HAL/PWM/: PWM.c PWM.h PWM_Debug.h PWM_Func.h
  group SOC_HAL/RTC
    SOC_HAL/RTC/: RTC.c RTC.h RTC_Debug.h RTC_Defconfig.h RTC_Func.h
  group SOC_HAL/Timers
    SOC_HAL/Timers/: Timer.c Timer.h
  group SOC_HAL/UART
    SOC_HAL/UART/: UART_LPC214X.c UART_LPC214X.h UART_LPC214X_Func.h
  group SOC_HAL/VIC
    SOC_HAL/VIC/: VIC.c VIC.h
